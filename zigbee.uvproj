# Keil uVision project zigbee.uvproj, settings and files
target Zigbee (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: zig_test +hex
  c flags: Optimize=9
  c define: xDEBUG ZB_PLATFORM_8051_SIM  KEIL C8051F120 xZB_UZ2410 xZB_UZ2410_256 ZB_TRACE_LEVEL=2 xZB_NS_BUILD xZB_DBG_NO_IDLE ZB_TRAFFIC_DUMP_ON xZB_TEXT_ONLY_TRACE xZB_ED_ROLE ZB_SECURITY xZB_USE_NVRAM xZB_NVRAM_WRITE_CFG
  c include: .\include;.\osif\include
  asm misc: DEFINE(ZB_UZ2410_256)
  group common
    ./common/: zb_address.c zb_scheduler.c zb_debug.c zb_bufpool.c
  group osif
    ./common/: zb_time.c
    ./osif/8051/: zb_8051_dummy.c zb_8051_serial.c zb_trace_8051.c zb_time_8051.c zb_8051_spi.c zb_mac_transport_8051_ser.c zb_uz2400_common.c zb_mac_transport_8051_spi.c zb_mac_transport_8051_direct.c
  group startup
    ./osif/8051/mk/keil/: low_level_init.c L51_BANK.A51 STARTUP.A51
  group init
    ./osif/8051/: zb_8051_nvram.c zb_8051_serial_init.c zb_8051_spi_init.c zb_time_8051_init.c zb_8051_xram.c zb_sysinit.c
    ./common/: zb_ib.c zb_init.c zb_bufpool_init.c zb_scheduler_init.c
  group nwk
    ./nwk/: nwk_cr_mesh_routing.c nwk_address_assign.c nwk_discovery.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_cr_tree_routing.c nwk_cr_route_discovery.c nwk_panid_conflict.c
  group nwk_join
    ./nwk/: nwk_cr_join.c nwk_join.c nwk_cr_formation.c nwk_cr_permit_join.c nwk_formation.c
  group aps
    ./aps/: aps_nwk_confirm.c aps_bind.c aps_dups.c aps_main.c aps_commands.c
  group mac
    ./common/: zb_random.c
    ./mac/: mac_common.c zb_uz2400.c mac.c mac_fcs.c mac_scan.c mac_associate.c zb_ns3.c mac_data.c mac_cr_associate.c mac_routines.c mac_cr_coordinator.c mac_cr_data.c zb_uz2410.c zb_uz2x_common.c mac_disturber.c
  group zdo
    ./zdo/: zdo_app.c af_rx.c zdo_disc_cli.c zdo_rx.c zdo_disc_srv.c zdo_common.c af_descriptor.c zdo_nwk_manage_srv.c zdo_nwk_manage_cli.c zdo_channel_manager.c test_profile.c zdo_bind_manage.c
    ./secur/: zdo_secur.c
  group secur
    ./secur/: apsme_secur.c secur_ccm.c nwk_secur.c aps_secur.c
  group aps_data
    ./tests/aps_data/: aps_data_test.c
  group nwk_formation
    ./tests/nwk_disc/: nwk_formation_test.c
  group nwk_discovery
    ./tests/nwk_disc/: nwk_disc_test.c
  group zdo_start_zc
    ./tests/zdo_startup/: zdo_start_zc.c
  group zdo_start_zr
    ./tests/zdo_startup/: zdo_start_zr.c
  group zdo_start_ze
    ./tests/zdo_startup/: zdo_start_ze.c
  group pcon_test
    ./tests/powercon_test/: pcon_test.c
  group crypto_test
    ./tests/encrypt/: crypt_test.c
  group mac_test
    ./tests/mac_test/: mac_test.c
  group delayed_buf
    ./tests/delayed_buf_test/: delayed_buf_test.c
  group scheduler_test
    ./tests/sched/: sched_test.c
  group zdo_start_sec_zc
    ./tests/zdo_start_secur/: zdo_start_sec_zc.c
  group zdo_start_sec_zr
    ./tests/zdo_start_secur/: zdo_start_sec_zr.c
  group zdo_start_sec_ze
    ./tests/zdo_start_secur/: zdo_start_sec_ze.c
  group security_request
    ./tests/request_key/: request_key_zc.c request_key_zr1.c
  group zdo_mgmt_nwk
    ./tests/zdo_mgmt_nwk/: zdo_zc_test_mgmt_nwk.c zdo_zr_test_mgmt_nwk.c
  group aps_group
    ./tests/aps_group/: aps_group_zc.c aps_group_zr1.c
  group nwk_leave
    ./tests/nwk_leave/: zdo_start_nleave_zr.c zdo_start_nleave_zc.c
  group nwk_reset
    ./tests/nwk_reset/: nwk_reset_ze.c nwk_reset_zc.c
  group TP_PRO_BV-26 - join
    ./tests/certification/TP_PRO_BV-26/: tp_pro_bv_26_DUTZR.c tp_pro_bv_26_gZC.c
  group TP_PRO_BV-27 - join 2 ZED
    ./tests/certification/TP_PRO_BV-27/: tp_pro_bv_27_DUTZED1.c tp_pro_bv_27_DUTZED2.c tp_pro_bv_27_gZC.c
  group TP_ZDO_BV-03 - discovery
    ./tests/certification/TP_ZDO_BV-03/: TP_ZDO_BV_03_DUTZC.c TP_ZDO_BV_03_ZED1.c TP_ZDO_BV_03_ZED2.c
  group TP_PRO_BV-28 - rejoin
    ./tests/certification/TP_PRO_BV-28/: tp_pro_bv_28_DUTZC.c tp_pro_bv_28_DUTZR.c tp_pro_bv_28_gZED.c
  group TP_APS_BV-27-I
    ./tests/certification/TP_APS_BV-27-I/: tp_aps_bv_27_i_DUTZR1.c tp_aps_bv_27_i_gZC.c tp_aps_bv_27_i_gZR2.c
  group TP_APS_BV-29-I
    ./tests/certification/TP_APS_BV-29-I/: tp_aps_bv_29_i_DUTZR.c tp_aps_bv_29_i_gZC.c
  group TP_ZDO_BV-05
    ./tests/certification/TP_ZDO_BV-05/: TP_ZDO_BV_05_DUTZC.c TP_ZDO_BV_05_ZED1.c TP_ZDO_BV_05_ZED2.c
  group TP_PRO_BV-36
    ./tests/certification/TP_PRO_BV-36/: tr_pro_bv_36_DUTZC.c tr_pro_bv_36_DUTZR.c
  group TP_PRO_BV-38
    ./tests/certification/TP_PRO_BV-38/: tr_pro_bv_38_DUTZC.c tr_pro_bv_38_DUTZR1.c
  group TP_PRO_BV-35
    ./tests/certification/TP_PRO_BV-35/: tr_pro_bv_35_DUTZC.c tr_pro_bv_35_DUTZR.c
  group TP_NWK_BV-04
    ./tests/certification/TP_NWK_BV-04/: tp_nwk_bv_04_gZC.c tp_nwk_bv_04_ZR.c
  group TP_ZDO_BV-06
    ./tests/certification/TP_ZDO_BV-06/: tp_zdo_bv_06_DUTZC.c tp_zdo_bv_06_gZED1.c tp_zdo_bv_06_gZED2.c
  group TP_APS_BV-33-I
    ./tests/certification/TP_APS_BV-33-I/: tp_aps_bv_33_i_DUTZC.c tp_aps_bv_33_i_gZED1.c tp_aps_bv_33_i_gZED2.c
  group nwk_sync
    ./tests/nwk_sync/: nwk_sync_zc.c nwk_sync_ze.c
  group nwk_status
    ./tests/nwk_status/: nwk_status_zc.c nwk_status_zr.c
  group aib_nib_pib_test
    ./tests/aib_nib_pib_test/: start_zc.c start_ze.c
  group zdo_active_ep
    ./tests/zdo_active_ep/: zdo_zc_test.c zdo_zr_test.c
  group secur_intra_pan_portability
    ./tests/secur_intra_pan_portability/: ipp_secur_zc.c ipp_secur_zr1.c ipp_secur_zr2.c
  group aps_dups_rej
    ./tests/aps_dup_reject/: aps_dups_rej_zc.c aps_dups_rej_ze.c
  group zdo_desc
    ./tests/zdo_desc/: zdo_zc_test_desc.c zdo_zr_test_desc.c
  group zdo_channel_mgr
    ./tests/zdo_channel_mgr/: zdo_zc_channel_mgr_test.c zdo_zr_channel_mgr_test.c
  group orphan_scan
    ./tests/orphan_scan/: orphan_scan_zc.c orphan_scan_zr.c
  group zdo_join_duration
    ./tests/zdo_join_duration/: zdo_join_duration_zc.c zdo_join_duration_zed1.c zdo_join_duration_zed2.c
  group TP_NWK_BV-12
    ./tests/certification/TP_NWK_BV-12/: tp_nwk_bv_12_ZC.c tp_nwk_bv_12_ZR.c tp_nwk_bv_12_ZR1.c
  group zdo_lqi
    ./tests/zdo_lqi/: zdo_zr1_lqi_test.c zdo_zc_lqi_test.c zdo_ze1_lqi_test.c zdo_ze2_lqi_test.c zdo_ze3_lqi_test.c
  group TP_PRO_BV-15_13_20
    ./tests/certification/TP_PRO_BV-15_13_20/: tp_pro_bv_15_zc.c tp_pro_bv_15_zed1.c tp_pro_bv_15_zr1.c tp_pro_bv_15_zr2.c
  group zdo_intra_pan_portability
    ./tests/zdo_intra_pan_portability/: intra_pan_portability_zc.c intra_pan_portability_ze.c intra_pan_portability_zr.c
  group disturber
    ./tests/mac_certification/disturber/: disturber.c
  group mac_scanning_03
    ./tests/mac_certification/scanning_03/: zdo_start_zc_s03.c
  group association_02_zc
    ./tests/mac_certification/association_02/: association_02_zc.c
  group association_01_zc
    ./tests/mac_certification/association_01/: association_01_zc.c
  group mac_scanning_04
    ./tests/mac_certification/scanning_04/: zdo_start_zc_s04.c
  group mac_scanning_05
    ./tests/mac_certification/scanning_05/: zdo_start_zc_s05.c
  group mac_scanning_06
    ./tests/mac_certification/scanning_06/: zdo_start_zc_s06.c
target nwk_formation (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: as above
  output: zig_test +hex
  c flags: Optimize=9
  c define: DEBUG ZB_PLATFORM_8051_SIM  KEIL C8051F120  ZB_TRACE_LEVEL=4
  c include: .\include;.\osif\include

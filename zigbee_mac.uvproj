# Keil uVision project zigbee_mac.uvproj, settings and files
target Zigbee_mac (MCS-51)
  device: C8051F120 Silicon Laboratories, Inc.
  cpu: IRAM(0-0xFF) XRAM(0-0x1FFF) IROM(0-0xFFFF) CLOCK(100000000) MDU_F120
  output: zig_test +hex
  c flags: Optimize=9
  c define: xDEBUG ZB_PLATFORM_8051_SIM  KEIL C8051F120 xZB_UZ2410 xZB_UZ2410_256 ZB_TRACE_LEVEL=3 xZB_NS_BUILD xZB_DBG_NO_IDLE ZB_TRAFFIC_DUMP_ON xZB_TEXT_ONLY_TRACE xZB_ED_ROLE xZB_SECURITY xZB_USE_NVRAM xZB_NVRAM_WRITE_CFG ZB_MAC_ONLY_STACK  ZB_MAC_EXT_DATA_REQ
  c include: .\include;.\osif\include
  asm misc: DEFINE(xZB_UZ2410_256)
  group common
    ./common/: zb_address.c zb_scheduler.c zb_debug.c zb_bufpool.c
  group osif
    ./common/: zb_time.c
    ./osif/8051/: zb_8051_dummy.c zb_8051_serial.c zb_trace_8051.c zb_time_8051.c zb_8051_spi.c zb_mac_transport_8051_ser.c zb_uz2400_common.c zb_mac_transport_8051_spi.c zb_mac_transport_8051_direct.c
  group startup
    ./osif/8051/mk/keil/: low_level_init.c L51_BANK.A51 STARTUP.A51
  group init
    ./osif/8051/: zb_8051_nvram.c zb_8051_serial_init.c zb_8051_spi_init.c zb_time_8051_init.c zb_8051_xram.c zb_sysinit.c
    ./common/: zb_ib.c zb_init.c zb_bufpool_init.c zb_scheduler_init.c
  group mac
    ./common/: zb_random.c
    ./mac/: mac_common.c zb_uz2400.c mac.c mac_fcs.c mac_scan.c mac_associate.c zb_ns3.c mac_data.c mac_cr_associate.c mac_routines.c mac_cr_coordinator.c mac_cr_data.c zb_uz2410.c zb_uz2x_common.c mac_disturber.c
  group secur
    ./secur/: apsme_secur.c secur_ccm.c nwk_secur.c aps_secur.c
  group disturber
    ./tests/mac_certification/disturber/: disturber.c
  group channel_access_01
    ./tests/mac_certification/channel_access_01/: channel_access_01.c
  group channel_access_02
    ./tests/mac_certification/channel_access_02/: channel_access_02.c
  group association_02_rfd
    ./tests/mac_certification/association_02/: association_02_rfd.c
  group association_01_rfd
    ./tests/mac_certification/association_01/: association_01_rfd.c
  group association_04_rfd
    ./tests/mac_certification/association_04/: association_04_rfd.c
  group association_06_rfd
    ./tests/mac_certification/association_06/: association_06_rfd.c
  group mac_scanning
    ./tests/mac_certification/scanning_03/: start_ze_s03.c
  group data_01
    ./tests/mac_certification/data_01/: data_01_ffd.c data_01_rfd.c
  group data_02
    ./tests/mac_certification/data_02/: data_02_ffd.c data_02_rfd.c
  group ack_frame_delivery_01
    ./tests/mac_certification/ack_frame_delivery_01/: ack_frame_delivery_01_ffd0.c ack_frame_delivery_01_ffd1.c
  group retries_01
    ./tests/mac_certification/retries_01/: retries_01_ffd0.c
  group warm_start_01
    ./tests/mac_certification/warm_start_01/: warm_start_01_ffd0.c warm_start_01_rfd1.c
  group warm_start_02
    ./tests/mac_certification/warm_start_02/: warm_start_02_ffd0.c warm_start_02_ffd1.c
  group frame_validation_05
    ./tests/mac_certification/frame_validation_05/: frame_validation_05_ffd0.c frame_validation_05_ffd1.c
target nwk_formation (MCS-51)
  device: C8051F124 Silicon Laboratories, Inc.
  cpu: as above
  output: zig_test +hex
  c flags: Optimize=9
  c define: DEBUG ZB_PLATFORM_8051_SIM  KEIL C8051F120  ZB_TRACE_LEVEL=4
  c include: .\include;.\osif\include

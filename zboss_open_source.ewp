# IAR project zboss_open_source.ewp, settings and files
configuration Zboss-CC25XX-Debug (8051, debug)
  General.DerivativeDescriptionFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\CC2530F256.i51
  ICC8051.CCDefines: ZB_PLATFORM_8051_SIM; ZB_CC25XX; ZB_IAR; ZB_SECURITY; ZB_ED_ROLE; xZB_TRACE_LEVEL=2; xZB_TRAFFIC_DUMP_ON
  ICC8051.OCCDataMemoryModel: 1
  ICC8051.OCCCodeMemoryModel: 1
  ICC8051.CCIncludePath2: include; osif\include
  ICC8051.CCStdIncludePath: $TOOLKIT_DIR$\INC\; $TOOLKIT_DIR$\INC\CLIB\
  ICC8051.CCOptLevel: 1
  ICC8051.CCOptStrategy: 0
  XLINK.XclFile: $TOOLKIT_DIR$\config\devices\Texas Instruments\lnk51ew_cc2530F256_banked.xcl
configuration Zboss-CC25XX-Release (8051)
  as the first configuration, except:
  ICC8051.CCOptLevel: 2
  group aps
    aps/: aps_bind.c aps_commands.c aps_dups.c aps_main.c aps_nwk_confirm.c
  group common
    common/: zb_address.c zb_bufpool.c zb_bufpool_init.c zb_debug.c zb_ib.c zb_init.c zb_random.c zb_scheduler.c zb_scheduler_init.c zb_time.c zb_trace.c
  group mac
    mac/: mac.c mac_associate.c mac_common.c mac_cr_associate.c mac_cr_coordinator.c mac_cr_data.c mac_data.c mac_disturber.c mac_fcs.c mac_routines.c mac_scan.c zb_cc25xx.c zb_cc25xx_common.c
  group nwk
    nwk/: nwk_address_assign.c nwk_cr_formation.c nwk_cr_join.c nwk_cr_mesh_routing.c nwk_cr_permit_join.c nwk_cr_route_discovery.c nwk_cr_tree_routing.c nwk_discovery.c nwk_formation.c nwk_internal.h nwk_join.c nwk_main.c nwk_neighbor.c nwk_nlme.c nwk_panid_conflict.c
  group osif/8051
    osif/8051/: zb_8051_dummy.c zb_8051_nvram.c zb_8051_serial.c zb_8051_serial_init.c zb_8051_spi.c zb_8051_spi_init.c zb_8051_xram.c zb_mac_transport_8051_direct.c zb_mac_transport_8051_ser.c zb_mac_transport_8051_spi.c zb_sysinit.c zb_time_8051.c zb_time_8051_init.c zb_trace_8051.c
  group secur
    secur/: aps_secur.c apsme_secur.c mac_secur.c nwk_secur.c secur_ccm.c zb_TI_cc25xx_secur_ccm.c zdo_secur.c
  group tests/zdo_startup
    tests/zdo_startup/: zdo_start_zc.c zdo_start_ze.c zdo_start_zr.c
  group zdo
    zdo/: af_descriptor.c af_rx.c zdo_app.c zdo_bind_manage.c zdo_channel_manager.c zdo_common.c zdo_common.h zdo_disc_cli.c zdo_disc_srv.c zdo_nwk_manage_cli.c zdo_nwk_manage_srv.c zdo_rx.c
